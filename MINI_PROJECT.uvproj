# Keil uVision project MINI_PROJECT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: MINI_PROJECT +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s delay.c types.h arduino_defines.h arduino.h arduino.c lcd.h lcd_defines.h lcd.c rtc.h rtc.c rtc_defies.h rtc_main.c kpm.c pin_connect_block.c
